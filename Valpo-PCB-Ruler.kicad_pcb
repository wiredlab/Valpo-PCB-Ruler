File: Valpo-PCB-Ruler.kicad_pcb (KiCad board)
At the start: 2 copper layers, 203.2 x 38.1 mm, 52 parts

Commit message: Port to KiCad 7
Other:
- net class Default removed
